# IAR project LoggingF407.ewp, settings and files
configuration LoggingF407 (ARM, debug)
  General.OGChipSelectEditMenu: STM32F407ZE ST STM32F407ZE
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  ICCARM.CCDefines: USE_HAL_DRIVER; STM32F407xx
  ICCARM.CCIncludePath2: ../Inc; ../Middlewares/Third_Party/LwIP/src/include; ../Middlewares/Third_Party/LwIP/system; ../Drivers/STM32F4xx_HAL_Driver/Inc; ../Drivers/STM32F4xx_HAL_Driver/Inc/Legacy; ../Middlewares/ST/STM32_USB_Device_Library/Core/Inc; ../Middlewares/ST/STM32_USB_Device_Library/Class/CustomHID/Inc; ../Drivers/CMSIS/Device/ST/STM32F4xx/Include; ../Middlewares/Third_Party/LwIP/src/include/lwip; ../Middlewares/Third_Party/LwIP/src/include/lwip/apps; ../Middlewares/Third_Party/LwIP/src/include/lwip/priv; ../Middlewares/Third_Party/LwIP/src/include/lwip/prot; ../Middlewares/Third_Party/LwIP/src/include/netif; ../Middlewares/Third_Party/LwIP/src/include/netif/ppp; ../Middlewares/Third_Party/LwIP/src/include/netif/ppp/polarssl; ../Middlewares/Third_Party/LwIP/src/include/posix; ../Middlewares/Third_Party/LwIP/src/include/posix/sys; ../Middlewares/Third_Party/LwIP/system/arch; ../Drivers/CMSIS/Include
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: Project.srec
  ILINK.IlinkOutputFile: LoggingF407.out
  ILINK.IlinkIcfFile: stm32f407xx_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Middlewares
    ./: 
  group Middlewares/LwIP
    ./: 
    ../Middlewares/Third_Party/LwIP/src/core/: udp.c raw.c sys.c inet_chksum.c tcp_in.c memp.c init.c ip.c pbuf.c def.c tcp.c netif.c stats.c mem.c dns.c tcp_out.c timeouts.c
    ../Middlewares/Third_Party/LwIP/src/core/ipv4/: dhcp.c ip4_frag.c icmp.c ip4.c igmp.c ip4_addr.c autoip.c etharp.c
    ../Middlewares/Third_Party/LwIP/src/netif/ppp/polarssl/: sha1.c des.c arc4.c md4.c md5.c
    ../Middlewares/Third_Party/LwIP/src/netif/ppp/: ipcp.c pppol2tp.c utils.c vj.c pppcrypt.c upap.c magic.c pppoe.c auth.c mppe.c multilink.c eui64.c ppp.c chap-md5.c ipv6cp.c eap.c pppapi.c demand.c ecp.c pppos.c fsm.c chap_ms.c lcp.c ccp.c chap-new.c
    ../Middlewares/Third_Party/LwIP/src/core/ipv6/: ip6_addr.c mld6.c dhcp6.c ethip6.c nd6.c ip6.c icmp6.c inet6.c ip6_frag.c
    ../Middlewares/Third_Party/LwIP/src/api/: api_lib.c tcpip.c netbuf.c sockets.c api_msg.c err.c netifapi.c netdb.c
    ../Middlewares/Third_Party/LwIP/src/netif/: lowpan6.c slipif.c ethernet.c
  group Middlewares/USB_Device_Library
    ./: 
    ../Middlewares/ST/STM32_USB_Device_Library/Core/Src/: usbd_ioreq.c usbd_core.c usbd_ctlreq.c
    ../Middlewares/ST/STM32_USB_Device_Library/Class/CustomHID/Src/: usbd_customhid.c
  group Application
    ./: 
  group Application/User
    ./: 
    ../Src/: main.c stm32f4xx_it.c usbd_conf.c usbd_desc.c usbd_custom_hid_if.c ethernetif.c usb_device.c lwip.c stm32f4xx_hal_msp.c
  group Application/EWARM
    ./:  startup_stm32f407xx.s
  group Drivers
    ./: 
  group Drivers/STM32F4xx_HAL_Driver
    ./: 
    ../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal_dma.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_pwr.c stm32f4xx_hal_gpio.c stm32f4xx_ll_usb.c stm32f4xx_hal_eth.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_pcd_ex.c stm32f4xx_hal.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_pcd.c stm32f4xx_hal_cortex.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_tim.c stm32f4xx_hal_adc_ex.c stm32f4xx_hal_adc.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_i2c.c stm32f4xx_hal_i2c_ex.c stm32f4xx_hal_spi.c stm32f4xx_hal_uart.c
  group Drivers/CMSIS
    ./: 
    ../Src/: system_stm32f4xx.c
